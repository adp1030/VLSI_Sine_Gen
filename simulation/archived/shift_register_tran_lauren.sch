v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N -10 130 460 130 {
lab=CLK}
N 70 -10 70 20 {
lab=Vphi1}
N 520 -10 520 20 {
lab=Vphi4}
N 540 20 580 20 {
lab=Vphi4}
N 70 50 90 50 {
lab=phi_1B}
N 370 -10 370 20 {
lab=Vphi3}
N 370 20 390 20 {
lab=Vphi3}
N 370 50 390 50 {
lab=phi_3B}
N 220 -10 220 20 {
lab=Vphi2}
N 220 50 240 50 {
lab=phi_2B}
N 220 20 240 20 {
lab=Vphi2}
N 370 50 370 60 {
lab=phi_3B}
N 220 50 220 60 {
lab=phi_2B}
N 70 50 70 60 {
lab=phi_1B}
N 10 100 10 130 {
lab=CLK}
N 160 100 160 130 {
lab=CLK}
N 310 100 310 130 {
lab=CLK}
N 460 100 460 130 {
lab=CLK}
N -10 360 460 360 {
lab=CLK}
N 70 220 70 250 {
lab=Vphi5}
N 520 220 520 250 {
lab=ff_8}
N 70 280 90 280 {
lab=phi_5B}
N 70 250 90 250 {
lab=Vphi5}
N 370 220 370 250 {
lab=Vphi7}
N 370 250 390 250 {
lab=Vphi7}
N 370 280 390 280 {
lab=phi_7B}
N 220 220 220 250 {
lab=Vphi6}
N 220 280 240 280 {
lab=phi_6B}
N 220 250 240 250 {
lab=Vphi6}
N 370 280 370 290 {
lab=phi_7B}
N 220 280 220 290 {
lab=phi_6B}
N 70 280 70 290 {
lab=phi_5B}
N 10 330 10 360 {
lab=CLK}
N 160 330 160 360 {
lab=CLK}
N 310 330 310 360 {
lab=CLK}
N 460 330 460 360 {
lab=CLK}
N 580 140 580 190 {
lab=Vphi4}
N -60 190 580 190 {
lab=Vphi4}
N -80 170 -80 280 {
lab=phi_4B}
N -80 280 -60 280 {
lab=phi_4B}
N -10 600 460 600 {
lab=CLK}
N 70 460 70 490 {
lab=ff_9}
N 520 460 520 490 {
lab=ff_12}
N 70 520 90 520 {
lab=ff_9B}
N 70 490 90 490 {
lab=ff_9}
N 370 460 370 490 {
lab=ff_11}
N 370 490 390 490 {
lab=ff_11}
N 370 520 390 520 {
lab=ff_11B}
N 220 460 220 490 {
lab=ff_10}
N 220 520 240 520 {
lab=ff_10B}
N 220 490 240 490 {
lab=ff_10}
N 370 520 370 530 {
lab=ff_11B}
N 70 520 70 530 {
lab=ff_9B}
N 10 570 10 600 {
lab=CLK}
N 160 570 160 600 {
lab=CLK}
N 310 570 310 600 {
lab=CLK}
N 460 570 460 600 {
lab=CLK}
N -10 830 460 830 {
lab=CLK}
N 70 690 70 720 {
lab=ff_13}
N 520 690 520 720 {
lab=ff_16}
N 540 720 580 720 {
lab=ff_16}
N 70 750 90 750 {
lab=ff_13B}
N 70 720 90 720 {
lab=ff_13}
N 370 690 370 720 {
lab=ff_15}
N 370 720 390 720 {
lab=ff_15}
N 370 750 390 750 {
lab=ff_15B}
N 220 690 220 720 {
lab=ff_14}
N 220 750 240 750 {
lab=ff_14B}
N 220 720 240 720 {
lab=ff_14}
N 370 750 370 760 {
lab=ff_15B}
N 220 750 220 760 {
lab=ff_14B}
N 70 750 70 760 {
lab=ff_13B}
N 10 800 10 830 {
lab=CLK}
N 160 800 160 830 {
lab=CLK}
N 310 800 310 830 {
lab=CLK}
N 460 800 460 830 {
lab=CLK}
N -60 660 580 660 {
lab=ff_12}
N -80 640 -80 750 {
lab=ff_12B}
N -80 750 -60 750 {
lab=ff_12B}
N 580 370 580 430 {
lab=ff_8}
N -60 430 580 430 {
lab=ff_8}
N -80 400 -80 520 {
lab=ff_8B}
N -80 520 -60 520 {
lab=ff_8B}
N -110 50 -110 870 {
lab=ff_16B}
N -110 50 -60 50 {
lab=ff_16B}
N 580 840 580 900 {
lab=ff_16}
N -140 900 580 900 {
lab=ff_16}
N -140 20 -140 900 {
lab=ff_16}
N -140 20 -60 20 {
lab=ff_16}
N -60 190 -60 250 {
lab=Vphi4}
N -60 430 -60 490 {
lab=ff_8}
N -60 660 -60 720 {
lab=ff_12}
N 500 50 500 170 {
lab=phi_4B}
N -80 170 500 170 {
lab=phi_4B}
N 50 20 90 20 {
lab=Vphi1}
N 200 50 220 50 {
lab=phi_2B}
N 350 50 370 50 {
lab=phi_3B}
N 580 20 580 140 {
lab=Vphi4}
N 500 20 540 20 {
lab=Vphi4}
N 350 20 370 20 {
lab=Vphi3}
N 200 20 220 20 {
lab=Vphi2}
N 50 250 70 250 {
lab=Vphi5}
N 200 250 220 250 {
lab=Vphi6}
N 350 250 370 250 {
lab=Vphi7}
N 500 250 520 250 {
lab=ff_8}
N 520 250 580 250 {
lab=ff_8}
N 580 250 580 370 {
lab=ff_8}
N 50 280 70 280 {
lab=phi_5B}
N 200 280 220 280 {
lab=phi_6B}
N 350 280 370 280 {
lab=phi_7B}
N 200 520 220 520 {
lab=ff_10B}
N 220 520 220 530 {
lab=ff_10B}
N 50 520 70 520 {
lab=ff_9B}
N 350 520 370 520 {
lab=ff_11B}
N -80 400 500 400 {
lab=ff_8B}
N 500 280 500 400 {
lab=ff_8B}
N 50 490 70 490 {
lab=ff_9}
N 200 490 220 490 {
lab=ff_10}
N 350 490 370 490 {
lab=ff_11}
N 500 490 580 490 {
lab=ff_12}
N 580 490 580 660 {
lab=ff_12}
N 500 520 500 640 {
lab=ff_12B}
N -80 640 500 640 {
lab=ff_12B}
N 50 720 70 720 {
lab=ff_13}
N 200 720 220 720 {
lab=ff_14}
N 350 720 370 720 {
lab=ff_15}
N 500 720 520 720 {
lab=ff_16}
N 520 720 540 720 {
lab=ff_16}
N 580 720 580 840 {
lab=ff_16}
N 500 750 500 870 {
lab=ff_16B}
N -110 870 500 870 {
lab=ff_16B}
N 50 750 70 750 {
lab=ff_13B}
N 200 750 220 750 {
lab=ff_14B}
N 350 750 370 750 {
lab=ff_15B}
N 50 50 70 50 {
lab=phi_1B}
C {madvlsi/tt_models.sym} 650 50 0 0 {
name=TT_MODELS
only_toplevel=false
value=".option wnflag=1
.param MC_SWITCH=0.0
.lib ~/skywater/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/models/sky130.lib.spice tt"
}
C {devices/code_shown.sym} 660 370 0 0 {name=SPICE only_toplevel=false value=".ic v(Vphi1)=0 v(Vphi2)=0 v(Vphi3)=0 v(Vphi4)=0 v(Vphi5)=0 v(Vphi6)=0 v(Vphi7)=0 v(ff_8)=0 v(ff_9)=1.8 v(ff_10)=1.8 v(ff_11)=1.8 v(ff_12)=1.8 v(ff_13)=1.8 v(ff_14)=1.8 v(ff_15)=1.8 v(ff_16)=1.8
.tran 0.01n 1u
.save all"}
C {madvlsi/vsource.sym} 670 260 0 0 {name=V_CLK
value="pulse(0 1.8 1n 1n 1n 4n 10n)"}
C {madvlsi/gnd.sym} 670 290 0 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} 670 230 2 0 {name=p1 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} -10 130 0 0 {name=p2 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 70 -10 2 0 {name=p9 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 520 -10 2 0 {name=p12 sig_type=std_logic lab=Vphi4}
C {devices/lab_pin.sym} 70 460 2 0 {name=p14 sig_type=std_logic lab=ff_9}
C {devices/lab_pin.sym} 220 460 2 0 {name=p15 sig_type=std_logic lab=ff_10}
C {devices/lab_pin.sym} 370 460 2 0 {name=p16 sig_type=std_logic lab=ff_11}
C {devices/lab_pin.sym} 520 460 2 0 {name=p17 sig_type=std_logic lab=ff_12}
C {devices/lab_pin.sym} 70 690 2 0 {name=p18 sig_type=std_logic lab=ff_13}
C {devices/lab_pin.sym} 220 690 2 0 {name=p19 sig_type=std_logic lab=ff_14}
C {devices/lab_pin.sym} 370 690 2 0 {name=p20 sig_type=std_logic lab=ff_15}
C {devices/lab_pin.sym} 520 690 2 0 {name=p21 sig_type=std_logic lab=ff_16}
C {devices/lab_pin.sym} 70 60 3 0 {name=p22 sig_type=std_logic lab=phi_1B}
C {devices/lab_pin.sym} 500 50 2 0 {name=p25 sig_type=std_logic lab=phi_4B}
C {devices/lab_pin.sym} 70 290 3 0 {name=p26 sig_type=std_logic lab=phi_5B}
C {devices/lab_pin.sym} 220 290 3 0 {name=p27 sig_type=std_logic lab=phi_6B}
C {devices/lab_pin.sym} 370 290 3 0 {name=p28 sig_type=std_logic lab=phi_7B}
C {devices/lab_pin.sym} 500 280 2 0 {name=p29 sig_type=std_logic lab=ff_8B}
C {devices/lab_pin.sym} 70 530 3 0 {name=p30 sig_type=std_logic lab=ff_9B}
C {devices/lab_pin.sym} 220 530 3 0 {name=p31 sig_type=std_logic lab=ff_10B}
C {devices/lab_pin.sym} 370 530 3 0 {name=p32 sig_type=std_logic lab=ff_11B}
C {devices/lab_pin.sym} 500 520 2 0 {name=p33 sig_type=std_logic lab=ff_12B}
C {devices/lab_pin.sym} 70 760 3 0 {name=p34 sig_type=std_logic lab=ff_13B}
C {devices/lab_pin.sym} 220 760 3 0 {name=p35 sig_type=std_logic lab=ff_14B}
C {devices/lab_pin.sym} 370 760 3 0 {name=p36 sig_type=std_logic lab=ff_15B}
C {devices/lab_pin.sym} 500 750 2 0 {name=p37 sig_type=std_logic lab=ff_16B}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/shift_register/lauren_mp2_files/csrl_dff3_lds.sym} -130 0 0 0 {name=X1}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/shift_register/lauren_mp2_files/csrl_dff3_lds.sym} 20 0 0 0 {name=X2}
C {devices/lab_pin.sym} 370 -10 2 0 {name=p38 sig_type=std_logic lab=Vphi3}
C {devices/lab_pin.sym} 370 60 3 0 {name=p39 sig_type=std_logic lab=phi_3B}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/shift_register/lauren_mp2_files/csrl_dff3_lds.sym} 170 0 0 0 {name=X3}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/shift_register/lauren_mp2_files/csrl_dff3_lds.sym} 320 0 0 0 {name=X4}
C {devices/lab_pin.sym} 220 -10 2 0 {name=p10 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 220 60 3 0 {name=p11 sig_type=std_logic lab=phi_2B}
C {devices/lab_pin.sym} -10 360 0 0 {name=p23 sig_type=std_logic lab=CLK}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/shift_register/lauren_mp2_files/csrl_dff3_lds.sym} -130 230 0 0 {name=X5}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/shift_register/lauren_mp2_files/csrl_dff3_lds.sym} 20 230 0 0 {name=X6}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/shift_register/lauren_mp2_files/csrl_dff3_lds.sym} 170 230 0 0 {name=X7}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/shift_register/lauren_mp2_files/csrl_dff3_lds.sym} 320 230 0 0 {name=X8}
C {devices/lab_pin.sym} -10 600 0 0 {name=p47 sig_type=std_logic lab=CLK}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/shift_register/lauren_mp2_files/csrl_dff3_lds.sym} -130 470 0 0 {name=X9}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/shift_register/lauren_mp2_files/csrl_dff3_lds.sym} 20 470 0 0 {name=X10}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/shift_register/lauren_mp2_files/csrl_dff3_lds.sym} 170 470 0 0 {name=X11}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/shift_register/lauren_mp2_files/csrl_dff3_lds.sym} 320 470 0 0 {name=X12}
C {devices/lab_pin.sym} -10 830 0 0 {name=p56 sig_type=std_logic lab=CLK}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/shift_register/lauren_mp2_files/csrl_dff3_lds.sym} -130 700 0 0 {name=X13}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/shift_register/lauren_mp2_files/csrl_dff3_lds.sym} 20 700 0 0 {name=X14}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/shift_register/lauren_mp2_files/csrl_dff3_lds.sym} 170 700 0 0 {name=X15}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/shift_register/lauren_mp2_files/csrl_dff3_lds.sym} 320 700 0 0 {name=X16}
C {devices/lab_pin.sym} 70 220 2 0 {name=p24 sig_type=std_logic lab=Vphi5}
C {devices/lab_pin.sym} 220 220 2 0 {name=p40 sig_type=std_logic lab=Vphi6}
C {devices/lab_pin.sym} 370 220 2 0 {name=p41 sig_type=std_logic lab=Vphi7}
C {devices/lab_pin.sym} 520 220 2 0 {name=p42 sig_type=std_logic lab=ff_8}
C {madvlsi/vsource.sym} 880 260 0 0 {name=Vdd
value=1.8}
C {madvlsi/gnd.sym} 880 290 0 0 {name=l2 lab=GND}
C {madvlsi/vdd.sym} 880 230 0 0 {name=l3 lab=VDD}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/dac/inverter.sym} 800 490 0 0 {name=X17}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/dac/inverter.sym} 870 490 0 0 {name=X18}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/dac/inverter.sym} 800 560 0 0 {name=X19}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/dac/inverter.sym} 870 560 0 0 {name=X20}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/dac/inverter.sym} 800 630 0 0 {name=X21}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/dac/inverter.sym} 870 630 0 0 {name=X22}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/dac/inverter.sym} 800 700 0 0 {name=X23}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/dac/inverter.sym} 870 700 0 0 {name=X24}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/dac/inverter.sym} 800 770 0 0 {name=X25}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/dac/inverter.sym} 870 770 0 0 {name=X26}
C {devices/lab_pin.sym} 720 490 2 1 {name=p3 sig_type=std_logic lab=Vphi1}
C {devices/lab_pin.sym} 720 560 2 1 {name=p4 sig_type=std_logic lab=Vphi2}
C {devices/lab_pin.sym} 720 630 2 1 {name=p5 sig_type=std_logic lab=Vphi3}
C {devices/lab_pin.sym} 720 700 2 1 {name=p6 sig_type=std_logic lab=Vphi4}
C {devices/lab_pin.sym} 720 770 2 1 {name=p7 sig_type=std_logic lab=Vphi5}
C {devices/lab_pin.sym} 720 840 2 1 {name=p8 sig_type=std_logic lab=Vphi6}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/dac/inverter.sym} 800 840 0 0 {name=X27}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/dac/inverter.sym} 800 910 0 0 {name=X28}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/dac/inverter.sym} 870 840 0 0 {name=X29}
C {/home/madvlsi/VLSI_Sine_Gen/simulation/dac/inverter.sym} 870 910 0 0 {name=X30}
C {devices/lab_pin.sym} 720 910 2 1 {name=p13 sig_type=std_logic lab=Vphi7}
C {devices/lab_pin.sym} 860 490 2 0 {name=p43 sig_type=std_logic lab=Vphi1f}
C {devices/lab_pin.sym} 860 560 2 0 {name=p44 sig_type=std_logic lab=Vphi2f}
C {devices/lab_pin.sym} 860 630 2 0 {name=p45 sig_type=std_logic lab=Vphi3f}
C {devices/lab_pin.sym} 860 700 2 0 {name=p46 sig_type=std_logic lab=Vphi4f}
C {devices/lab_pin.sym} 860 770 2 0 {name=p48 sig_type=std_logic lab=Vphi5f}
C {devices/lab_pin.sym} 860 840 2 0 {name=p49 sig_type=std_logic lab=Vphi6f}
C {devices/lab_pin.sym} 860 910 2 0 {name=p50 sig_type=std_logic lab=Vphi7f}
