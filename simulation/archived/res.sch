v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 1470 1760 0 0 {name=R10
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {madvlsi/gnd.sym} 1450 1760 1 0 {name=l1 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 1470 1820 0 0 {name=R1
W=0.35
L=3.5
model=res_xhigh_po
spiceprefix=X
mult=1}
C {madvlsi/gnd.sym} 1450 1820 1 0 {name=l2 lab=GND}
