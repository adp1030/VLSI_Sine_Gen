v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1470 1940 0 1 {name=C3 model=cap_mim_m3_1 W=10 L=8 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1470 1970 3 0 {name=p1 sig_type=std_logic lab=bot}
C {devices/lab_pin.sym} 1470 1910 1 0 {name=p2 sig_type=std_logic lab=top}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1650 1940 0 1 {name=C1 model=cap_mim_m3_1 W=10 L=8 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1650 1970 3 0 {name=p3 sig_type=std_logic lab=bot}
C {devices/lab_pin.sym} 1650 1910 1 0 {name=p4 sig_type=std_logic lab=top}
