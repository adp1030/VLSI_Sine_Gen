v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 250 20 280 20 {
lab=phi_2}
N 250 50 280 50 {
lab=phi_2B}
N 390 20 420 20 {
lab=phi_3}
N 390 50 420 50 {
lab=phi_3B}
N 110 210 140 210 {
lab=phi_5}
N 110 240 140 240 {
lab=phi_5B}
N 250 210 280 210 {
lab=phi_6}
N 250 240 280 240 {
lab=phi_6B}
N 390 210 420 210 {
lab=phi_7}
N 390 240 420 240 {
lab=phi_7B}
N 530 50 530 140 {
lab=phi_4B}
N 530 20 560 20 {
lab=phi_4}
N 600 20 600 150 {
lab=phi_4}
N -10 150 560 150 {
lab=phi_4}
N -10 180 -10 210 {
lab=phi_4}
N -10 210 0 210 {
lab=phi_4}
N -20 140 530 140 {
lab=phi_4B}
N -20 140 -20 210 {
lab=phi_4B}
N -20 240 0 240 {
lab=phi_4B}
N 110 400 140 400 {
lab=ff_9}
N 110 430 140 430 {
lab=ff_9B}
N 250 400 280 400 {
lab=ff_10}
N 250 430 280 430 {
lab=ff_10B}
N 390 400 420 400 {
lab=ff_11}
N 390 430 420 430 {
lab=ff_11B}
N 110 590 140 590 {
lab=ff_13}
N 110 620 140 620 {
lab=ff_13B}
N 250 590 280 590 {
lab=ff_14}
N 250 620 280 620 {
lab=ff_14B}
N 390 590 420 590 {
lab=ff_15}
N 390 620 420 620 {
lab=ff_15B}
N 530 430 530 520 {
lab=ff_12B}
N 530 400 560 400 {
lab=ff_12}
N 600 400 600 530 {
lab=ff_12}
N -10 530 560 530 {
lab=ff_12}
N -10 560 -10 590 {
lab=ff_12}
N -10 590 0 590 {
lab=ff_12}
N -20 520 530 520 {
lab=ff_12B}
N -20 520 -20 590 {
lab=ff_12B}
N -20 620 0 620 {
lab=ff_12B}
N 530 210 560 210 {
lab=ff_8}
N 600 210 600 340 {
lab=ff_8}
N -10 340 560 340 {
lab=ff_8}
N -10 370 -10 400 {
lab=ff_8}
N -10 400 0 400 {
lab=ff_8}
N 530 240 530 330 {
lab=ff_8B}
N -20 330 530 330 {
lab=ff_8B}
N -20 330 -20 400 {
lab=ff_8B}
N -20 430 0 430 {
lab=ff_8B}
N 530 620 530 730 {
lab=ff_16B}
N -40 730 530 730 {
lab=ff_16B}
N -40 50 -40 640 {
lab=ff_16B}
N -40 50 -0 50 {
lab=ff_16B}
N 530 590 560 590 {
lab=ff_16}
N 600 590 600 740 {
lab=ff_16}
N -50 740 560 740 {
lab=ff_16}
N -50 20 -50 650 {
lab=ff_16}
N -50 20 -0 20 {
lab=ff_16}
N 20 120 490 120 {
lab=CLK}
N 20 310 490 310 {
lab=CLK}
N 20 500 490 500 {
lab=CLK}
N 20 710 490 710 {
lab=CLK}
N -20 210 -20 240 {
lab=phi_4B}
N -10 150 -10 180 {
lab=phi_4}
N 120 180 120 210 {
lab=phi_5}
N 260 180 260 210 {
lab=phi_6}
N 400 180 400 210 {
lab=phi_7}
N 120 -10 120 20 {
lab=phi_1}
N 260 -10 260 20 {
lab=phi_2}
N 400 -10 400 20 {
lab=phi_3}
N 540 -10 540 20 {
lab=phi_4}
N 540 180 540 210 {
lab=ff_8}
N -20 400 -20 430 {
lab=ff_8B}
N -10 340 -10 370 {
lab=ff_8}
N -20 590 -20 620 {
lab=ff_12B}
N -10 530 -10 560 {
lab=ff_12}
N -40 640 -40 730 {
lab=ff_16B}
N -50 650 -50 740 {
lab=ff_16}
N 120 370 120 400 {
lab=ff_9}
N 260 370 260 400 {
lab=ff_10}
N 400 370 400 400 {
lab=ff_11}
N 540 370 540 400 {
lab=ff_12}
N 120 560 120 590 {
lab=ff_13}
N 260 560 260 590 {
lab=ff_14}
N 400 560 400 590 {
lab=ff_15}
N 540 560 540 590 {
lab=ff_16}
N 120 50 120 100 {
lab=phi_1B}
N 260 50 260 100 {
lab=phi_2B}
N 400 50 400 100 {
lab=phi_3B}
N 70 100 70 120 {
lab=CLK}
N 210 100 210 120 {
lab=CLK}
N 350 100 350 120 {
lab=CLK}
N 490 100 490 120 {
lab=CLK}
N 560 150 600 150 {
lab=phi_4}
N 560 20 600 20 {
lab=phi_4}
N 560 210 600 210 {
lab=ff_8}
N 560 340 600 340 {
lab=ff_8}
N 560 400 600 400 {
lab=ff_12}
N 560 530 600 530 {
lab=ff_12}
N 560 590 600 590 {
lab=ff_16}
N 560 740 600 740 {
lab=ff_16}
N 120 240 120 290 {
lab=phi_5B}
N 260 240 260 290 {
lab=phi_6B}
N 400 240 400 290 {
lab=phi_7B}
N 490 290 490 310 {
lab=CLK}
N 350 290 350 310 {
lab=CLK}
N 210 290 210 310 {
lab=CLK}
N 70 290 70 310 {
lab=CLK}
N 120 430 120 480 {
lab=ff_9B}
N 400 430 400 480 {
lab=ff_11B}
N 260 430 260 480 {
lab=ff_10B}
N 490 480 490 500 {
lab=CLK}
N 350 480 350 500 {
lab=CLK}
N 210 480 210 500 {
lab=CLK}
N 70 480 70 500 {
lab=CLK}
N 120 620 120 670 {
lab=ff_13B}
N 260 620 260 670 {
lab=ff_14B}
N 400 620 400 670 {
lab=ff_15B}
N 70 670 70 710 {
lab=CLK}
N 210 670 210 710 {
lab=CLK}
N 350 670 350 710 {
lab=CLK}
N 490 670 490 710 {
lab=CLK}
N 890 120 890 230 {
lab=#net1}
N 890 190 970 190 {
lab=#net1}
N 1040 190 1070 190 {
lab=#net2}
N 120 50 140 50 {
lab=phi_1B}
N 120 20 140 20 {
lab=phi_1}
N 110 20 120 20 {
lab=phi_1}
N 110 50 120 50 {
lab=phi_1B}
C {madvlsi/tt_models.sym} 650 -20 0 0 {
name=TT_MODELS
only_toplevel=false
value=".option wnflag=1
.param MC_SWITCH=0.0
.lib ~/skywater/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/models/sky130.lib.spice tt"
}
C {devices/code_shown.sym} 660 370 0 0 {name=SPICE only_toplevel=false value="
.ic v(phi_1)=0 v(phi_2)=0 v(phi_3)=0 v(phi_4)=0 v(phi_5)=0 v(phi_6)=0 v(phi_7)=0 v(ff_8)=0 v(ff_9)=1.8 v(ff_10)=1.8 v(ff_11)=1.8 v(ff_12)=1.8 v(ff_13)=1.8 v(ff_14)=1.8 v(ff_15)=1.8 v(ff_16)=1.8 v(phi_1B)=1.8 v(phi_2B)=1.8 v(phi_3B)=1.8 v(phi_4B)=1.8 v(phi_5B)=1.8 v(phi_6B)=1.8 v(phi_7B)=1.8 v(ff_8B)=1.8 v(ff_9B)=0 v(ff_10B)=0 v(ff_11B)=0 v(ff_12B)=0 v(ff_13B)=0 v(ff_14B)=0 v(ff_15B)=0 v(ff_16B)=0
.tran 0.01n 1u
.save all"}
C {/home/madvlsi/Documents/VLSI_Sine_Gen/simulation/shift_register/csrl_dff3_lds.sym} -70 0 0 0 {name=X1}
C {/home/madvlsi/Documents/VLSI_Sine_Gen/simulation/shift_register/csrl_dff3_lds.sym} 70 0 0 0 {name=X2}
C {/home/madvlsi/Documents/VLSI_Sine_Gen/simulation/shift_register/csrl_dff3_lds.sym} 210 0 0 0 {name=X3}
C {/home/madvlsi/Documents/VLSI_Sine_Gen/simulation/shift_register/csrl_dff3_lds.sym} 350 0 0 0 {name=X4}
C {/home/madvlsi/Documents/VLSI_Sine_Gen/simulation/shift_register/csrl_dff3_lds.sym} -70 190 0 0 {name=X5}
C {/home/madvlsi/Documents/VLSI_Sine_Gen/simulation/shift_register/csrl_dff3_lds.sym} 70 190 0 0 {name=X6}
C {/home/madvlsi/Documents/VLSI_Sine_Gen/simulation/shift_register/csrl_dff3_lds.sym} 210 190 0 0 {name=X7}
C {/home/madvlsi/Documents/VLSI_Sine_Gen/simulation/shift_register/csrl_dff3_lds.sym} 350 190 0 0 {name=X8}
C {/home/madvlsi/Documents/VLSI_Sine_Gen/simulation/shift_register/csrl_dff3_lds.sym} -70 380 0 0 {name=X9}
C {/home/madvlsi/Documents/VLSI_Sine_Gen/simulation/shift_register/csrl_dff3_lds.sym} 70 380 0 0 {name=X10}
C {/home/madvlsi/Documents/VLSI_Sine_Gen/simulation/shift_register/csrl_dff3_lds.sym} 210 380 0 0 {name=X11}
C {/home/madvlsi/Documents/VLSI_Sine_Gen/simulation/shift_register/csrl_dff3_lds.sym} 350 380 0 0 {name=X12}
C {/home/madvlsi/Documents/VLSI_Sine_Gen/simulation/shift_register/csrl_dff3_lds.sym} -70 570 0 0 {name=X13}
C {/home/madvlsi/Documents/VLSI_Sine_Gen/simulation/shift_register/csrl_dff3_lds.sym} 70 570 0 0 {name=X14}
C {/home/madvlsi/Documents/VLSI_Sine_Gen/simulation/shift_register/csrl_dff3_lds.sym} 210 570 0 0 {name=X15}
C {/home/madvlsi/Documents/VLSI_Sine_Gen/simulation/shift_register/csrl_dff3_lds.sym} 350 570 0 0 {name=X16}
C {madvlsi/vsource.sym} 670 260 0 0 {name=V_CLK
value="pulse(0 1.8 1ns 1ns 1ns 4ns 10ns)"}
C {madvlsi/gnd.sym} 670 290 0 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} 670 230 2 0 {name=p1 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 20 120 0 0 {name=p2 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 20 310 0 0 {name=p3 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 20 500 0 0 {name=p4 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 20 710 0 0 {name=p5 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 120 180 2 0 {name=p6 sig_type=std_logic lab=phi_5}
C {devices/lab_pin.sym} 260 180 2 0 {name=p7 sig_type=std_logic lab=phi_6}
C {devices/lab_pin.sym} 400 180 2 0 {name=p8 sig_type=std_logic lab=phi_7}
C {devices/lab_pin.sym} 120 -10 2 0 {name=p9 sig_type=std_logic lab=phi_1}
C {devices/lab_pin.sym} 260 -10 2 0 {name=p10 sig_type=std_logic lab=phi_2}
C {devices/lab_pin.sym} 400 -10 2 0 {name=p11 sig_type=std_logic lab=phi_3}
C {devices/lab_pin.sym} 540 -10 2 0 {name=p12 sig_type=std_logic lab=phi_4}
C {devices/lab_pin.sym} 540 180 2 0 {name=p13 sig_type=std_logic lab=ff_8}
C {devices/lab_pin.sym} 120 370 2 0 {name=p14 sig_type=std_logic lab=ff_9}
C {devices/lab_pin.sym} 260 370 2 0 {name=p15 sig_type=std_logic lab=ff_10}
C {devices/lab_pin.sym} 400 370 2 0 {name=p16 sig_type=std_logic lab=ff_11}
C {devices/lab_pin.sym} 540 370 2 0 {name=p17 sig_type=std_logic lab=ff_12}
C {devices/lab_pin.sym} 120 560 2 0 {name=p18 sig_type=std_logic lab=ff_13}
C {devices/lab_pin.sym} 260 560 2 0 {name=p19 sig_type=std_logic lab=ff_14}
C {devices/lab_pin.sym} 400 560 2 0 {name=p20 sig_type=std_logic lab=ff_15}
C {devices/lab_pin.sym} 540 560 2 0 {name=p21 sig_type=std_logic lab=ff_16}
C {devices/lab_pin.sym} 120 100 2 0 {name=p22 sig_type=std_logic lab=phi_1B}
C {devices/lab_pin.sym} 260 100 2 0 {name=p23 sig_type=std_logic lab=phi_2B}
C {devices/lab_pin.sym} 400 100 2 0 {name=p24 sig_type=std_logic lab=phi_3B}
C {devices/lab_pin.sym} 530 100 2 0 {name=p25 sig_type=std_logic lab=phi_4B}
C {devices/lab_pin.sym} 120 290 2 0 {name=p26 sig_type=std_logic lab=phi_5B}
C {devices/lab_pin.sym} 260 290 2 0 {name=p27 sig_type=std_logic lab=phi_6B}
C {devices/lab_pin.sym} 400 290 2 0 {name=p28 sig_type=std_logic lab=phi_7B}
C {devices/lab_pin.sym} 530 290 2 0 {name=p29 sig_type=std_logic lab=ff_8B}
C {devices/lab_pin.sym} 120 480 2 0 {name=p30 sig_type=std_logic lab=ff_9B}
C {devices/lab_pin.sym} 260 480 2 0 {name=p31 sig_type=std_logic lab=ff_10B}
C {devices/lab_pin.sym} 400 480 2 0 {name=p32 sig_type=std_logic lab=ff_11B}
C {devices/lab_pin.sym} 530 480 2 0 {name=p33 sig_type=std_logic lab=ff_12B}
C {devices/lab_pin.sym} 120 670 2 0 {name=p34 sig_type=std_logic lab=ff_13B}
C {devices/lab_pin.sym} 260 670 2 0 {name=p35 sig_type=std_logic lab=ff_14B}
C {devices/lab_pin.sym} 400 670 2 0 {name=p36 sig_type=std_logic lab=ff_15B}
C {devices/lab_pin.sym} 530 670 2 0 {name=p37 sig_type=std_logic lab=ff_16B}
C {madvlsi/vsource.sym} 890 260 0 0 {name=V_HI
value="pwl(0 0 25n 0 26n 1.8 40n 1.8 41n 0)"}
C {madvlsi/gnd.sym} 890 290 0 0 {name=l2 lab=GND}
C {devices/lab_pin.sym} 890 80 2 0 {name=p40 sig_type=std_logic lab=phi_1}
C {/home/madvlsi/Documents/VLSI_Sine_Gen/simulation/shift_register/inverter.sym} 1050 190 0 0 {name=X17}
C {devices/lab_pin.sym} 1110 190 2 0 {name=p38 sig_type=std_logic lab=phi_1B}
C {madvlsi/gnd.sym} 1000 220 0 0 {name=l3 lab=GND}
C {madvlsi/vdd.sym} 1000 160 0 0 {name=l4 lab=VDD}
